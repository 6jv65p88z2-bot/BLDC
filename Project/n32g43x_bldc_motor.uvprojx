# Keil uVision project n32g43x_bldc_motor.uvprojx, settings and files
target MotorControl (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G435RB Nationstech
  pack: Nationstech.N32G43x_DFP.0.9.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bldc_motor +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\Lib\inc;..\Libraries\Lib\src;..\Libraries\Startup;..\Libraries\SysConfig;..\Libraries\SysCore;..\Source\App;..\Source\Bsp;..\Source\Motor;..\Source\AD56xx
  asm include: ..\Head
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ../Libraries/Startup/: startup_n32g43x.s
  group System_Config
    ../Libraries/SysConfig/: system_n32g43x.c
  group System_Stdlib
    ../Libraries/Lib/src/: misc.c n32g43x_adc.c n32g43x_can.c n32g43x_comp.c n32g43x_dac.c n32g43x_dma.c n32g43x_exti.c n32g43x_flash.c n32g43x_gpio.c n32g43x_opamp.c n32g43x_rcc.c n32g43x_tim.c n32g43x_usart.c n32g43x_spi.c
  group Bsp
    ../Source/Bsp/: bsp_uart.c bsp_systick.c n32g43x_it.c bsp_uart_cb.c bsp_led.c bsp_key.c bsp_opa.c bsp_dac.c bsp_timer.c bsp_pwm.c bsp_pwm_cb.c bsp_io.c bsp_adc.c bsp_adc_cb.c
  group App
    ../Source/App/: main.c
  group ReadMe
    ../ReadMe/: ReadMe.txt
